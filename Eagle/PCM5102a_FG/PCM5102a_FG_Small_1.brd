# Repository ryood/I2S_FG

## EAGLE design Eagle/PCM5102a_FG/PCM5102a_FG_Small_1.brd

Parts:
C1, C2: 22pF; C050-024X044
C3, C4, C6, C9, C12, C13: 0.1uF; C025-024X044
C5, C11, C16: 10uF; E2,5-5
C7, C8: 2.2uF; C075-063X106
C10: 2200p; C050-035X075
C15: 100uF; E2,5-7
D1: 1S4; DO35-7
IC1: PSOC_5LP_PROTOTIYPING_KIT; DIL52-8
IC2: PCM5102A; DIL20-6
IC3: TA48M033F; TO220V
JP1: AQM0802; 1X05
JP2: ROTARY_ENCODER; 1X03
JP3: KEYPAD; 1X08
JP4: WAVE_OUT; 1X03
JP5: DC4.5V; 1X02
LED1: BLUE; LED3MM
Q1: 20MHz; HC49/S
R1: 470; 0207/7
R2: 0; 0207/7
R3: 4.7k; 0207/7
R4, R5: 100k; 0207/7

Connections:
+3V3: C3.2, C6.2, C9.2, C13.1, C15.+, C16.+, D1.A, IC1.26, IC2.1, IC2.8, IC2.17, IC2.20, IC3.3 (VO), R4.1
AGND: C6.1, C8.1, C9.1, C10.2, C16.-, IC2.3, IC2.9, JP4.3, R2.2
BCK: IC1.50, IC2.13
DC4.5V: C12.1, D1.C, IC3.1 (VI), JP5.1, R3.2
DGND: C1.2, C2.2, C3.1, C4.2, C5.-, C11.-, C12.2, C13.2, C15.-, IC1.25, IC2.10, IC2.11, IC2.12, IC2.16, IC2.19, IC3.2 (GND), JP1.5, JP2.3, JP5.2, LED1.K (C), R5.2
DIN: IC1.49, IC2.14
I2C_RST: IC1.4, JP1.2
I2C_SCL: IC1.3, JP1.3
I2C_SDA: IC1.2, JP1.4
I2C_SW: C11.+, IC1.5, JP1.1
LRCK: IC1.48, IC2.15
unnamed: C4.1, C5.+, IC2.18
unnamed: C7.2, IC2.2
unnamed: C7.1, IC2.4
unnamed: C8.2, IC2.5
unnamed: IC2.6, JP4.1, R1.2
unnamed: C10.1, JP4.2, R1.1
unnamed: IC1.27, JP3.1
unnamed: IC1.28, JP3.2
unnamed: IC1.29, JP3.3
unnamed: IC1.30, JP3.4
unnamed: IC1.31, JP3.5
unnamed: IC1.32, JP3.6
unnamed: IC1.33, JP3.7
unnamed: IC1.34, JP3.8
unnamed: C2.1, IC1.10, Q1.1
unnamed: C1.1, IC1.11, Q1.2
unnamed: IC1.51, R2.1
unnamed: IC1.23, R4.2, R5.1
unnamed: LED1.A, R3.1
RE_A: IC1.16, JP2.1
RE_B: IC1.17, JP2.2

Notes on the sheet:
※Q1, R1, R2, C10はピンソケットで実装

Board: 2 copper layers, 70.8 x 66.0 mm, 31 parts (0 on the bottom side), 32 nets.

## Commit log

2016-01-31 384kHz/24bit
2016-01-31 384kHz/32bit
2016-02-11 Add: Fritzing File
2016-02-11 正弦波形を0.9倍に
2016-02-11 32bitテーブル/32768要素数
2016-02-11 Lchのみ出力
2016-02-11 __REV()関数を使用
2016-02-14 Add:UI_Test Project
2016-02-14 UI_Test: KeyScan OK (P2[0..7])
2016-02-14 UI_Test: Rotary Encoder
2016-02-14 Add: I2S_FG_UI Fritzing Files
2016-02-18 UI_Test: 電卓のようにキーパッドから周波数値を入力
2016-02-19 Add: I2S_FG_UI+Power_Supply+PCM5102A.fzz
2016-02-19 Add: PrototypingKit_FG_Test
2016-02-19 PrototypingKit_FG_Test: Use Ext XTAL
2016-02-21 Add:I2S_FG_UI+Power_Supply+PCM5102A.fzz
2016-02-21 PrototypingKit_FG_Test: LCD
2016-02-21 Add: I2C LCD Direct Dirve Fritzing file
2016-02-21 Update: PrototypingKit_FG_Test
2016-02-21 Add: Eagle File
2016-02-21 Update: Eagle Files
2016-02-24 電源電圧測定
2016-02-24 LCDのコントラスト調整
2016-02-24 基板図修正: PCM5102a_FG_Small_1.sch/brd
2016-02-27 PCM5102a_FG_Small_1.sch/brd Add: SBD
2016-02-27 PCM5102a_FG_Small_1.brd 修正
2016-03-01 ハードウェア完成
2016-03-03 テスト表更新、状態遷移図修正
2016-03-03 PrototypingKit_FG.cydsn: UIを整理
2016-03-03 PrototypingKit_FG: Rotary Encoderによる周波数値の増減(範囲制限にBugあり)
2016-03-03 PrototypingKit_FG: Rotary Encoderによる周波数値の増減(修正)
2016-03-20 画像更新
2016-03-26 Sampling Rate: 19200Hz 状態遷移図更新
2016-03-26 サンプリング周波数を382kHzに
2016-03-29 ノコギリ波の出力
2016-03-29 UI状態遷移図更新
2016-03-29 UIを修正
2016-07-22 設定値をEEPROMに保存
